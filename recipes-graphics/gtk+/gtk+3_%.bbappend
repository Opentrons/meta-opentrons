PACKAGECONFIG_append = " x11"
