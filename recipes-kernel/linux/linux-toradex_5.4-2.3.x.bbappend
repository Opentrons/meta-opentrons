FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += " file://SPI-CAN.cfg"
